<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ebi_sdram_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ebi_sram_example.ewp</path>
  </project>
  <batchBuild/>
</workspace>


